# Keil uVision project PM_SH79F3283.uvproj, settings and files
target PM_SH79F3283 (MCS-51)
  device: SH79F3283 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(12000000)
  output: PM_SH79F3283
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\Include;..\..\Source\Buzzer;..\..\Source\Fan;..\..\Source\Isr;..\..\Source\Light;..\..\Source\Motor;..\..\Source\Sys;..\..\Source\Sysclk;..\..\Source\Timer;..\..\Source\Uart;..\..\Source;..\..\Source\Hood;..\..\Source\Eeprom
  group include
    ../../Include/: adc_define.h api_ext.h cpu.h dac_ext.h eeprom_ext.h interrput.h LED_define.h pca_define.h SH79F328.h SH79F3283xx.h Spi_define.h sysclk_define.h timer_define.h Twi_define.h Twi_ext.h
    ./: STARTUP.A51
  group source
    ../../Source/: defines.h main.c sw_timer.c sw_timer.h task.c task.h wdt.c wdt.h
    ../../Source/Buzzer/: buzzer.c buzzer.h
    ../../Source/Fan/: fan.c fan.h
    ../../Source/Isr/: interrupt.c
    ../../Source/Light/: light.c light.h
    ../../Source/Motor/: motor.c motor.h
    ../../Source/Sys/: system.c
    ../../Source/Sysclk/: SetSysclk.c
    ../../Source/Timer/: Timer3.c Timer4.c Timer5.c
    ../../Source/Uart/: ringbuffer.c ringbuffer.h Uart2PM.c Uart2PM.h
    ../../Source/Hood/: hood.c hood.h
    ../../Source/Eeprom/: eeprom_user.c eeprom_user.h
