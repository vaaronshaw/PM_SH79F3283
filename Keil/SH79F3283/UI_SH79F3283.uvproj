# Keil uVision project UI_SH79F3283.uvproj, settings and files
target UI_SH79F3283 (MCS-51)
  device: SH79F3283 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(12000000)
  output: UI_SH79F3283
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\Include;..\..\Source;..\..\Source\Button;..\..\Source\Isr;..\..\Source\Sys;..\..\Source\Sysclk;..\..\Source\Timer;..\..\Source\Uart;..\..\Source\Display;..\..\Source\Buzzer;..\..\Source\Light;..\..\Source\Motor;..\..\Source\Fan
  group Include
    ./: STARTUP.A51
    ../../Include/: adc_define.h api_ext.h cpu.h dac_ext.h eeprom_ext.h interrput.h LED_define.h pca_define.h SH79F328.h Spi_define.h sysclk_define.h timer_define.h Twi_define.h Twi_ext.h
  group Source
    ../../Source/: defines.h main.c sw_timer.c sw_timer.h task.c task.h wdt.c wdt.h
    ../../Source/Button/: button.c button.h
    ../../Source/Isr/: interrupt.c
    ../../Source/Sys/: system.c
    ../../Source/Sysclk/: SetSysclk.c Sysclk_Test.c
    ../../Source/Timer/: Timer3.c Timer4.c Timer5.c
    ../../Source/Uart/: Uart2PM.c Uart2PM.h ringbuffer.c ringbuffer.h
    ../../Source/Display/: display.c display.h
    ../../Source/Buzzer/: buzzer.c buzzer.h
    ../../Source/Light/: light.c light.h
    ../../Source/Motor/: motor.c motor.h
    ../../Source/Fan/: fan.c fan.h
